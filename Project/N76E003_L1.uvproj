# Keil uVision project N76E003_L1.uvproj, settings and files
target N76E003_L1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: N76E003_L1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\FwLib\Include;..\User\inc
  group Startup
    ../FwLib/Startup/: STARTUP.A51
  group usr-src
    ../User/src/: adc.c interrupt.c ird_remote.c led.c main.c PID.c pwm.c task.c timer.c udelay.c
  group usr-inc
    ../User/inc/: adc.h interrupt.h ird_remote.h led.h PID.h pwm.h task.h timer.h userdefine.h udelay.h
  group common-src
    ../FwLib/Common/: Common.c Delay.c
  group common-inc
    ../FwLib/Include/: Common.h Function_Define.h N76E003.h SFR_Macro.h Delay.h
